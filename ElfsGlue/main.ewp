# IAR project main.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    $EW_DIR$/Project/C++/: _cpp2.cpp
    ./: conf_loader.cpp config_data.c config_data.h main.c
    $EW_DIR$/Project/ErrorLogger/: ErrorLogger.cpp
    $EW_DIR$/Project/include/: func.asm

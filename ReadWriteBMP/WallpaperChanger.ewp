# IAR project WallpaperChanger.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration debag2 (ARM)
  as the first configuration, except:
  group (top)
    ../C++/: _cpp2.cpp
    ../include/: func.asm
    ./: main.cpp

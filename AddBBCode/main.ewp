# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS; LNG_RUS; DEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release_RUS (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OLDFUNCTIONS; LNG_RUS; NDEBUG
configuration Release_ENG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: OLDFUNCTIONS; LNG_ENG; NDEBUG
  group (top)
    $EW_DIR$/Project/C++/: _cpp2.cpp
    ./: colorGUI.c conf_loader.cpp config_data.c fontGUI.c gui.c main.cpp pictureGUI.c SmilesMenu.c softkeys.cpp
    $EW_DIR$/Project/include/: func.asm
    header/: LANGUAGE_ENG.h LANGUAGE_RUS.h
